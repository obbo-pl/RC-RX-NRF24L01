# Repository obbo-pl/RC-RX-NRF24L01

File README.md:

# RC-RX-NRF24L01
RC receiver with NRF24L01 module and compatible with the CABELL protocol

##### Main features:

- dimensions: 50.0 * 22.9 * 12.2mm (without case),
- weight: approx. 9g (without case),
- 2.4GHz NRF24L01 G-24 module,
- communication protocol compatible with CABELL v3,
- 8 channels,
- supply voltage 4.0V - 6.2V,
- serial port and I2C for telemetry,
- parameter configuration via serial port (9600bps),
- output signal levels: 5V,

For more information: [www.obbo.pl](https://obbo.pl/rc-rx-nrf24l01)

## KiCad design hardware/RX-Module-nRF24L01.kicad_pcb

Parts:
C1, C5: 10u; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
C3, C4, C6, C7, C8: 100n; C_0805K
C9, C10: 18p; C_0805K
J1, J2, J3, J4, J5, J6, J7, J8, J10, J11: Conn_01x03; PinHeader_3x01_P2.54mm_Horizontal
J9: Conn_01x01; Pin_D1.0mm_L10.0mm_LooseFit
R1: 68k*; R_0805K
R2: 22k; R_0805K
R3, R5, R6: 10k; R_0805K
R4: 47k*; R_0805K
R7, R8: 3k3; R_0805K
U1: TPS73601DBV; SOT-23-5
U2: TPS73633DBV; SOT-23-5
U3: ATmega328-AU; TQFP-32_7x7mm_P0.8mm
U4: NRF24L01_Breakout; nRF24L01-GT24_Breakout_PinHeader_2x04
Y1: 16MHz; Crystal_SMD_5032-4Pin_5.0x3.2mm_HandSoldering

Connections:
+3V3: C5.1, C6.1, U2.5 (OUT), U4.2 (VCC)
+5V: C1.1, C3.1, R1.1, R3.1, R7.1, R8.1, U1.5 (OUT), U2.1 (IN), U2.3 (EN), U3.4 (VCC), U3.6 (VCC), U3.18 (AVCC)
+BATT: J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, R4.1, U1.1 (IN), U1.3 (EN)
/CE: R5.1, U3.11 (PD7), U4.3 (CE)
/CH1: J1.1, U3.14 (PB2)
/CH5: J5.1, U3.23 (PC0)
/CH6: J6.1, U3.24 (PC1)
/CH7: J7.1, U3.25 (PC2)
/CH8: J8.1, U3.26 (PC3)
/MISO: U3.10 (PD6), U4.7 (MISO)
/MISO_CH3: J3.1, U3.16 (PB4)
/MOSI: U3.9 (PD5), U4.6 (MOSI)
/MOSI_CH2: J2.1, U3.15 (PB3)
/NRF_CSN: U3.12 (PB0), U4.4 (~CSN)
/RESET: C7.1, J9.1, R3.2, U3.29 (~RESET~/PC6)
/Rx: J10.1, U3.30 (PD0)
/SCK: U3.2 (PD4), U4.5 (SCK)
/SCK_CH4: J4.1, U3.17 (PB5)
/SCL: J11.2, R8.2, U3.28 (PC5)
/SDA: J11.1, R7.2, U3.27 (PC4)
/Tx: J10.2, U3.31 (PD1)
/VBAT: C8.1, R4.2, R6.1, U3.22 (ADC7)
/xtl1: C9.1, U3.7 (XTAL1/PB6), Y1.1
/xtl2: C10.2, U3.8 (XTAL2/PB7), Y1.3
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, J1.3, J2.3, J3.3, J4.3, J5.3, J6.3, J7.3, J8.3, J10.3, J11.3, R2.2, R5.2, R6.2, U1.2 (GND), U2.2 (GND), U3.3 (GND), U3.5 (GND), U3.21 (GND), U4.1 (GND), Y1.2, Y1.4
unnamed: C4.1, U3.20 (AREF)
unnamed: R1.2, R2.1, U1.4 (FB)

Notes on the sheet:
Serial
I2C
Vref 1.1V
4.8V - 6.2V

Board: 2 copper layers, 50.0 x 22.9 mm, 33 parts (9 on the bottom side), 27 nets.

## Commit log

2020-09-09 New terminal command
2020-09-09 Failsafe pulse mode configuration
2020-10-31 printed case
2021-05-08 throttle disarm disable option
2021-06-02 status LED and bind button connected via I2C socket
2023-03-02 symbol update
